# Keil uVision project Basic_Bootloader.uvprojx, settings and files
target BOOTLOADER (6180000::V6.18::ARMCLANG)
  device: R7FA6T2BD3CFP Renesas
  pack: Renesas.RA_DFP.3.7.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Basic_Bootloader +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.7.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: LFS_READONLY,LFS_NO_MALLOC,LFS_NO_DEBUG,LFS_NO_ERROR,LFS_NO_WARN
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\ra\fsp\src\bsp\mcu\all;.\include;.\Application\inc;.\libraries\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group Application
    ./Application/src/: key.c boot_it.c int_flash.c mx25_driver.c flash_spi.c fw_storage.c serial_flash.c dfu.c test.c
  group Lib\LittleFS
    ./libraries/littlefs/: lfs.c lfs_util.c
  group Linker
    ./: memory_regions.scat
software components: Compiler:I/O:STDOUT 1.2.0, Flex Software:RA Configuration 1.0.0
