# Keil uVision project 01_Three_Phase.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: R7FA6T2BD Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) ELITTLE
  output: 01_Three_Phase
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.6.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\src\Application\main
  asm include: .\src\Application\main
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
    ./src/Application/main/: application_main.c application_main.h
  group Application
    ./src/Application/main/: application_main.c
software components: Flex Software:RA Configuration 1.0.0
