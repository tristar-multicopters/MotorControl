# Keil uVision project POC_ADC_Wheel.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: R7FA6T2BB Renesas
  pack: Renesas.RA_DFP.3.7.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: POC_ADC_Wheel
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.7.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
