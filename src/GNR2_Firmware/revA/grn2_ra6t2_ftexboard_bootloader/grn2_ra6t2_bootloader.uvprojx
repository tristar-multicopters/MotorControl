# Keil uVision project grn2_ra6t2_bootloader.uvprojx, settings and files
target Bootloader(Compile) (6180000::V6.18::ARMCLANG)
  device: R7FA6T2BD Renesas
  pack: Renesas.RA_DFP.3.7.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: grn2_ra6t2_bootloader +hex
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.7.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3
  c define: LFS_READONLY,LFS_NO_MALLOC,LFS_NO_DEBUG,LFS_NO_ERROR,LFS_NO_WARN
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\Ftex\inc;.\Libraries\littlefs
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group Application
    ./Ftex/src/: key.c boot_it.c fw_storage.c fw_update.c
  group Middleware
    ./Ftex/src/: uCAL_SPI.c mx25_driver.c external_flash.c internal_flash.c uart_debug.c
  group Lib\LittleFS
    ./Libraries/littlefs/: lfs.c lfs_util.c
  group Linker
    ./: memory_regions.scat
software components: Compiler:I/O:STDOUT 1.2.0, Flex Software:RA Configuration 1.0.0
