# Keil uVision project gnr2_ra6t2_RTX5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6T2BB Renesas
  pack: Renesas.RA_DFP.3.7.0
  cpu: CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) ELITTLE
  output: RTX5_Project
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.6.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\FTEX\inc;.\FTEX\inc\application;.\FTEX\inc\application_vehicle;.\FTEX\inc\application_motor;.\FTEX\inc\application_communications;.\FTEX\inc\middleware_vehicle;.\FTEX\inc\middleware_communications;.\FTEX\inc\middleware_motor;.\FTEX\inc\peripherals_abstraction;.\FTEX\inc\peripherals_abstraction\CANOpen;.\CANopen-stack\config;.\CANopen-stack\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x8000000 size 0x4000
  memory RVCT6: RAM 0x2000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group Application
    ./FTEX/src/application/: gnr_main.c ASSERT_FTEX.c
    ./: gnr_ra6t2_it.c gnr_parameters.h
    ./FTEX/inc/application/: board_hardware.h
  group Application/Communications
    ./FTEX/src/application_communications/: comm_config.c comm_interface.c comm_parameters.c co_gnr2_specs.c comm_tasks.c
    ./FTEX/inc/application_communications/: comm_defines.h
  group Application/Vehicle
    ./FTEX/src/application_vehicle/: vc_config.c vc_interface.c vc_tasks.c
    ./FTEX/inc/application_vehicle/: vc_defines.h vc_parameters.h vc_parameters_ebgo.h vc_parameters_grizzly.h
  group Application/Motor
    ./FTEX/src/application_motor/: mc_config.c mc_interface.c mc_parameters.c mc_tasks.c
    ./FTEX/inc/application_motor/: parameters_conversion.h parameters_conversion_ra6t2.h pmsm_motor_parameters.h power_stage_parameters.h drive_parameters.h mc_tuning.h pmsm_motor_parameters_ebgo.h pmsm_motor_parameters_grizzly.h
  group Middleware/Communications
    ./FTEX/src/middleware_communications/: can_logger.c lcd_apt_comm.c
  group Middleware/Vehicle
    ./FTEX/src/middleware_vehicle/: md_interface.c brake.c powertrain_management.c motor_selection.c power_enable.c throttle.c vc_state_machine.c pedal_speed_sensor.c pedal_torque_sensor.c wheel_speed_sensor.c
  group Middleware/Motor
    ./FTEX/src/middleware_motor/: mc_math.c ics_ra6t2_pwm_curr_fdbk.c bus_voltage_sensor.c circle_limitation.c hall_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c speed_pos_fdbk.c speed_torq_ctrl.c mc_state_machine.c virtual_bus_voltage_sensor.c virtual_speed_sensor.c feed_forward_ctrl.c flux_weakening_ctrl.c sto_pll_speed_pos_fdbk.c foldback.c rotor_pos_obs.c ramp_mngr.c signal_filtering.c lookup_table.c
  group Peripherals/Abstraction
    ./FTEX/src/peripherals_abstraction/: regular_conversion_manager.c pulse_frequency_agt.c pulse_frequency_gpt.c uCAL_GPIO.c uCAL_UART.c
    ./FTEX/src/peripherals_abstraction/CANOpen/: co_can_callbacks.c co_can_ra6t2.c co_nvm_ra6t2.c co_timer_ra6t2.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group CANOpen_Lib
    ./CANopen-stack/source/: co_core.c co_csdo.c co_dict.c co_emcy.c co_if.c co_if_can.c co_if_nvm.c co_if_timer.c co_lss.c co_nmt.c co_obj.c co_para.c co_pdo.c co_ssdo.c co_sync.c co_tmr.c co_ver.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS:Keil RTX5 5.5.4, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:Startup 1.0.0, Flex Software:RA Configuration 1.0.0
