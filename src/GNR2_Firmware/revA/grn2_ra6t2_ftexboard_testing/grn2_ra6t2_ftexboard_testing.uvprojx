# Keil uVision project grn2_ra6t2_ftexboard_testing.uvprojx, settings and files
target Main App (6180000::V6.18::ARMCLANG)
  device: R7FA6T2BB Renesas
  pack: Renesas.RA_DFP.3.7.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU2 CLOCK(12000000) ELITTLE
  output: grn2_ra6t2_ftexboard_testing
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Slauncher\rasc_launcher.bat" "3.7.0" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3
  c define: LFS_NO_MALLOC,LFS_NO_DEBUG,LFS_NO_ERROR,LFS_NO_WARN
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\FTEX\inc\Application;.\FTEX\inc\Middleware;.\Libraries\littlefs
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
  group Application
    ./FTEX/src/Application/: test_main.c external_flash_storage.c internal_memory_storage.c serial_process.c serial_response.c
  group Middleware
    ./FTEX/src/Middleware/: serial_communication.c external_memory.c external_memory_driver.c external_memory_spi.c internal_memory.c
  group Lib\LittleFS
    ./Libraries/littlefs/: lfs.c lfs_util.c
software components: Flex Software:RA Configuration 1.0.0
