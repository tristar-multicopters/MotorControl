# Keil uVision project DualDrive_RR.uvprojx, settings and files
target DualDrive_RR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: R-IN32M4-CL2 Renesas
  pack: Keil.R-IN32M4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DualDrive_RR +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,
  c include: ../Inc;          ../Drivers/STM32G4xx_HAL_Driver/Inc;          ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;          ../Middlewares/Third_Party/FreeRTOS/Source/include;          ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;          ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;          ../MCSDK_v5.4.6/MotorControl/MCSDK/MCLib/Any/Inc;          ../MCSDK_v5.4.6/MotorControl/MCSDK/MCLib/G4xx/Inc;          ../MCSDK_v5.4.6/MotorControl/MCSDK/UILibrary/Inc;          ../MCSDK_v5.4.6/MotorControl/MCSDK/SystemDriveParams;          ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;          ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User
    ../Src/: main.c app_freertos.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g4xx_mc_it.c mc_parameters.c ui_task.c user_interface.c dac_ui.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_hal_cordic.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.6/MotorControl/MCSDK/MCLib/Any/Src/: fast_div.c feed_forward_ctrl.c flux_weakening_ctrl.c revup_ctrl.c sto_cordic_speed_pos_fdbk.c bus_voltage_sensor.c circle_limitation.c digital_output.c hall_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_bus_voltage_sensor.c virtual_speed_sensor.c
    ../MCSDK_v5.4.6/MotorControl/lib/: libmc-keil_M4.lib
    ../MCSDK_v5.4.6/MotorControl/MCSDK/MCLib/G4xx/Src/: ics_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.6/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
software components: CMSIS:CORE 5.5.0, Device:R-IN32M4 Drivers:ADC 1.0.0, Device:R-IN32M4 Drivers:TIMER 1.0.0, Device:R-IN32M4 Drivers:UART 1.0.0, Device:Startup 1.0.0
