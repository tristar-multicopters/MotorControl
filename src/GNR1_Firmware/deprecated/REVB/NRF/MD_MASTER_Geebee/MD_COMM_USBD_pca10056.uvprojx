# Keil uVision project MD_COMM_USBD_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: .\config;.\FTEX_MODULES;.\NRF_MODULES\components;.\NRF_MODULES\components\boards;.\NRF_MODULES\components\drivers_nrf\nrf_soc_nosd;.\NRF_MODULES\components\libraries\atomic;.\NRF_MODULES\components\libraries\atomic_fifo;.\NRF_MODULES\components\libraries\balloc;.\NRF_MODULES\components\libraries\bsp;.\NRF_MODULES\components\libraries\button;.\NRF_MODULES\components\libraries\cli;.\NRF_MODULES\components\libraries\experimental_section_vars;.\NRF_MODULES\components\libraries\fifo;.\NRF_MODULES\components\libraries\log;.\NRF_MODULES\components\libraries\log\src;.\NRF_MODULES\components\libraries\memobj;.\NRF_MODULES\components\libraries\queue;.\NRF_MODULES\components\libraries\ringbuf;.\NRF_MODULES\components\libraries\strerror;.\NRF_MODULES\components\libraries\spi_mngr;.\NRF_MODULES\components\libraries\timer;.\NRF_MODULES\components\libraries\uart;.\NRF_MODULES\components\libraries\util;.\NRF_MODULES\components\libraries\usbd;.\NRF_MODULES\components\libraries\usbd\class\cdc;.\NRF_MODULES\components\libraries\usbd\class\cdc\acm;.\NRF_MODULES\external\fprintf;.\NRF_MODULES\external\utf_converter;.\NRF_MODULES\external\freertos\config;.\NRF_MODULES\external\freertos\portable\ARM\nrf52;.\NRF_MODULES\external\freertos\portable\CMSIS\nrf52;.\NRF_MODULES\external\freertos\source\include;.\NRF_MODULES\integration\nrfx;.\NRF_MODULES\integration\nrfx\legacy;.\NRF_MODULES\modules\nrfx;.\NRF_MODULES\modules\nrfx\hal;.\NRF_MODULES\modules\nrfx\drivers\include;.\NRF_MODULES\modules\nrfx\drivers\src\prs;.\NRF_MODULES\components\libraries\delay
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
    ./NRF_MODULES/external/freertos/config/: FreeRTOSConfig.h
  group Board Definition
    ./NRF_MODULES/components/boards/: boards.c
  group Board Support
    ./NRF_MODULES/components/libraries/bsp/: bsp.c
  group FreeRTOS
    ./NRF_MODULES/external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./NRF_MODULES/external/freertos/source/portable/MemMang/: heap_1.c
    ./NRF_MODULES/external/freertos/portable/ARM/nrf52/: port.c
    ./NRF_MODULES/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nRF_Drivers
    ./NRF_MODULES/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c nrf_drv_ppi.c nrf_drv_spi.c
    ./NRF_MODULES/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ./NRF_MODULES/modules/nrfx/soc/: nrfx_atomic.c
    ./NRF_MODULES/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_usbd.c nrfx_uart.c nrfx_uarte.c nrfx_saadc.c nrfx_systick.c nrfx_power.c nrfx_timer.c nrfx_ppi.c nrfx_spim.c
    ./NRF_MODULES/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ./NRF_MODULES/components/libraries/button/: app_button.c
    ./NRF_MODULES/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./NRF_MODULES/components/libraries/timer/: app_timer_freertos.c
    ./NRF_MODULES/components/libraries/atomic/: nrf_atomic.c
    ./NRF_MODULES/components/libraries/balloc/: nrf_balloc.c
    ./NRF_MODULES/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./NRF_MODULES/components/libraries/memobj/: nrf_memobj.c
    ./NRF_MODULES/components/libraries/ringbuf/: nrf_ringbuf.c
    ./NRF_MODULES/components/libraries/strerror/: nrf_strerror.c
    ./NRF_MODULES/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ./NRF_MODULES/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ./NRF_MODULES/components/libraries/uart/: app_uart_fifo.c retarget.c
    ./NRF_MODULES/components/libraries/fifo/: app_fifo.c
    ./NRF_MODULES/components/libraries/atomic_fifo/: nrf_atfifo.c
    ./NRF_MODULES/components/libraries/queue/: nrf_queue.c
  group nRF_Log
    ./NRF_MODULES/components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group FTEX Modules
    ./FTEX_MODULES/: frame_communication_protocol.c host_comm.c md_comm.c regular_conversion_manager.c throttle.c uart_frame_communication_protocol.c usbd_comm.c vc_config.c vc_tasks.c vc_state_machine.c torque_distribution.c mc_defines.h board_hardware.c brake.c canbus_management.c mcp25625_comm.c spi_interface.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
