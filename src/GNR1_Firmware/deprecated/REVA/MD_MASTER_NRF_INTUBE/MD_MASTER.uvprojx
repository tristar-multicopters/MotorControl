# Keil uVision project MD_MASTER.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: .\NRF_MODULES;.\NRF_MODULES\boards;.\NRF_MODULES\drivers_nrf\nrf_soc_nosd;.\NRF_MODULES\libraries\atomic;.\NRF_MODULES\libraries\balloc;.\NRF_MODULES\libraries\bsp;.\NRF_MODULES\libraries\delay;.\NRF_MODULES\libraries\experimental_section_vars;.\NRF_MODULES\libraries\fifo;.\NRF_MODULES\libraries\log;.\NRF_MODULES\libraries\log\src;.\NRF_MODULES\libraries\memobj;.\NRF_MODULES\libraries\ringbuf;.\NRF_MODULES\libraries\strerror;.\NRF_MODULES\libraries\uart;.\NRF_MODULES\libraries\util;.\NRF_MODULES\fprintf;.\NRF_MODULES\integration\nrfx;.\NRF_MODULES\integration\nrfx\legacy;.\NRF_MODULES\modules\nrfx;.\NRF_MODULES\modules\nrfx\drivers\include;.\NRF_MODULES\modules\nrfx\hal;.\;.\FREERTOS_MODULES\freertos\source\include;.\FREERTOS_MODULESl\freertos\config;.\FREERTOS_MODULES\freertos\portable\ARM\nrf52;.\FREERTOS_MODULES\freertos\portable\CMSIS\nrf52;.\NRF_MODULES\libraries\button;.\NRF_MODULES\modules\nrfx\drivers\src\prs;.\NRF_MODULES\libraries\timer;.\NRF_MODULES\libraries\atomic_fifo;.\NRF_MODULES\libraries\sortlist;.\FTEX_MODULES;.\NRF_MODULES\libraries\spi_mngr;.\NRF_MODULES\libraries\queue;.\NRF_MODULES\libraries\fds;.\NRF_MODULES\libraries\fstorage;.\NRF_MODULES\libraries\crc16
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c FreeRTOSConfig.h sdk_config.h
    ./FTEX_MODULES/: vc_tasks.c vc_config.c
  group Board Definition
    ./NRF_MODULES/boards/: boards.c
  group nRF_Drivers
    ./NRF_MODULES/integration/nrfx/legacy/: nrf_drv_uart.c nrf_drv_clock.c nrf_drv_spi.c
    ./NRF_MODULES/modules/nrfx/soc/: nrfx_atomic.c
    ./NRF_MODULES/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ./NRF_MODULES/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ./NRF_MODULES/modules/nrfx/drivers/src/: nrfx_gpiote.c nrfx_clock.c nrfx_timer.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_uarte.c nrfx_uart.c
    ./NRF_MODULES/modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ./NRF_MODULES/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ./NRF_MODULES/libraries/fifo/: app_fifo.c
    ./NRF_MODULES/libraries/uart/: app_uart_fifo.c retarget.c
    ./NRF_MODULES/libraries/atomic/: nrf_atomic.c
    ./NRF_MODULES/libraries/balloc/: nrf_balloc.c
    ./NRF_MODULES/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ./NRF_MODULES/libraries/memobj/: nrf_memobj.c
    ./NRF_MODULES/libraries/ringbuf/: nrf_ringbuf.c
    ./NRF_MODULES/libraries/strerror/: nrf_strerror.c
    ./NRF_MODULES/libraries/atomic_fifo/: nrf_atfifo.c
    ./NRF_MODULES/libraries/sortlist/: nrf_sortlist.c
    ./NRF_MODULES/libraries/timer/: app_timer_freertos.c
    ./NRF_MODULES/libraries/button/: app_button.c
    ./NRF_MODULES/libraries/spi_mngr/: nrf_spi_mngr.c
    ./NRF_MODULES/libraries/queue/: nrf_queue.c
    ./NRF_MODULES/libraries/fds/: fds.c
    ./NRF_MODULES/libraries/crc16/: crc16.c
    ./NRF_MODULES/libraries/fstorage/: nrf_fstorage_nvmc.c nrf_fstorage.c
  group nRF_Log
    ./NRF_MODULES/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group Communications
    ./FTEX_MODULES/: frame_communication_protocol.c md_comm.c uart_frame_communication_protocol.c md_code_reg.h
  group FreeRTOS
    ./FREERTOS_MODULES/freertos/source/: croutine.c event_groups.c list.c queue.c readme.txt stream_buffer.c tasks.c timers.c
    ./FREERTOS_MODULES/freertos/source/portable/MemMang/: heap_1.c
    ./FREERTOS_MODULES/freertos/portable/ARM/nrf52/: port.c
    ./FREERTOS_MODULES/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Analog
    ./FTEX_MODULES/: regular_conversion_manager.c
  group Storage
    ./FTEX_MODULES/: flashconfig.c
  group Vehicule Control
    ./FTEX_MODULES/: throttle.c derate.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
