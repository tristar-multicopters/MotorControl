# Keil uVision project MD_MASTER.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: .\config;.\FTEX_MODULES;.\NRF_MODULES\components;.\NRF_MODULES\components\boards;.\NRF_MODULES\components\drivers_nrf\nrf_soc_nosd;.\NRF_MODULES\components\libraries\atomic;.\NRF_MODULES\components\libraries\atomic_fifo;.\NRF_MODULES\components\libraries\balloc;.\NRF_MODULES\components\libraries\bsp;.\NRF_MODULES\components\libraries\button;.\NRF_MODULES\components\libraries\cli;.\NRF_MODULES\components\libraries\experimental_section_vars;.\NRF_MODULES\components\libraries\fifo;.\NRF_MODULES\components\libraries\fstorage;.\NRF_MODULES\components\libraries\log;.\NRF_MODULES\components\libraries\log\src;.\NRF_MODULES\components\libraries\memobj;.\NRF_MODULES\components\libraries\queue;.\NRF_MODULES\components\libraries\ringbuf;.\NRF_MODULES\components\libraries\strerror;.\NRF_MODULES\components\libraries\spi_mngr;.\NRF_MODULES\components\libraries\timer;.\NRF_MODULES\components\libraries\uart;.\NRF_MODULES\components\libraries\util;.\NRF_MODULES\components\libraries\usbd;.\NRF_MODULES\components\libraries\usbd\class\cdc;.\NRF_MODULES\components\libraries\usbd\class\cdc\acm;.\NRF_MODULES\external\fprintf;.\NRF_MODULES\external\utf_converter;.\NRF_MODULES\integration\nrfx;.\NRF_MODULES\integration\nrfx\legacy;.\NRF_MODULES\modules\nrfx;.\NRF_MODULES\modules\nrfx\hal;.\NRF_MODULES\modules\nrfx\drivers\include;.\NRF_MODULES\modules\nrfx\drivers\src\prs;.\NRF_MODULES\components\libraries\delay;.\NRF_MODULES\components\softdevice\common
  asm define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x20038000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x38000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
  group nRF_Drivers
    ./NRF_MODULES/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c nrf_drv_ppi.c nrf_drv_spi.c
    ./NRF_MODULES/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ./NRF_MODULES/modules/nrfx/soc/: nrfx_atomic.c
    ./NRF_MODULES/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c nrfx_uarte.c nrfx_saadc.c nrfx_systick.c nrfx_power.c nrfx_timer.c nrfx_ppi.c nrfx_spim.c
    ./NRF_MODULES/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ./NRF_MODULES/modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ./NRF_MODULES/components/libraries/util/: app_util_platform.c app_error.c app_error_weak.c
    ./NRF_MODULES/components/libraries/queue/: nrf_queue.c
    ./NRF_MODULES/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ./NRF_MODULES/components/softdevice/common/: nrf_sdh.c
    ./NRF_MODULES/components/libraries/atomic/: nrf_atomic.c
  group FTEX Modules
    ./FTEX_MODULES/: board_hardware.c brake.c canbus_management.c derate.c euart_manager.c frame_communication_protocol.c host_comm.c iref_control.c lcd_bafang_comm.c lcd_eggrider_comm.c mc_defines.h mcp25625_comm.c md_comm.c md_interface.c pedal_assist.c pid_regulator.c regular_conversion_manager.c spi_interface.c storage_management.c throttle.c torque_distribution.c uart_frame_communication_protocol.c vc_config.c vc_interface.c vc_state_machine.c vc_tasks.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Compiler:Event Recorder 1.4.0, Device:Startup 8.35.0
